Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-05-17T13:17:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon May 17 13:17:21 2021* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{9FF8CA10-F49B-48F5-905F-060AA694EF1C}\ifc* Database version: 5507* Database creation date: Mon May 17 13:17:02 2021* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon May 17 13:17:19 2021* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon May 17 13:17:19 2021* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcTransportElement: ECOVimecE10_1250x1000mm, NBS_VimecAccessibilityLtd_VrtclLftngPltfrms_ECOVimecE10:ECOVimecE10_1250x1000mm:315344
In: Level 0
Type - PredefinedType: ELEVATOR; Classification: Pr_65_80_47_95 (Uniclass2015); Material: NBS_VimecAccessibilityLtd_Vimec7040, NBS_VimecAccessibilityLtd_Similinox, NBS_Glass_Single
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VimecAccessibilityLtd_VerticalLiftingPlatforms_ECOVimecE10_1250x1000mm; ManufacturerName: Vimec Accessibility Ltd; ManufacturerURL: www.vimechomelifts.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/4c4hxl3d; NBSDescription: Platform lifts; NBSReference: 90-80-65/350; ProductInformation: https://vimechomelifts.co.uk/product-catalogue/homelifts/ecovimec-homelift/; Revision: n/a; Uniclass2015Title: Vertical lifting platforms; Uniclass2015Code: Pr_65_80_47_95; Uniclass2015Version: Products v1.20; Version: 1
Type - NBS_Data - Standard: n/a; RatedLoadMinimum: 400 kg STD/500 kg HL/500kg HL + couterweight; DriveType: Automatic; ControlDeviceType: Push button panel; ControlFeatures: Single Press (telescopic doors) Deadman's controls (hinged doors); ElectricalSupply: Single Phase 230V 50Hz; Accessories: Autodialler, GSM Autodialler, Remote Landing pushes, I-Button, Floor Announcement, Horizontal Cabin Mirror, Vertical Cabin Mirror, LCD display on landing pushes, Stainless Steel Landing Pushes, Collective Call, Kit for flooring by others, Shaft lighting; CarriageType: Fully enclosed; CarrierFrameMaterial: Various; CarrierFrameFinish: Vimec 7040; CarrierFrameColour: Vimec 7040; CarrierInfillMaterial: Steel or Glass; CarrierInfillFinish: Coated Steel Colur Type, Stainless Steel, Glass; CarrierInsertColour: Coated Steel Colur Type: matt white.Moods: Contemporary,New Classic,nordic,Natural, Country Chis, Urban Glass: Transparent or smoke Grey; DoorsArrangement: Single, Adjacent, Through; DoorsType: Hinged orTelescopic; DoorsClearOpeningWidthMinimum: Panel Door 600,650,700,750,800,860 Panoramic Panel door 800, 860 Aluminium Panoramic Door 600,650,700,750,800,860 Double Himged Door 700,750,800 Automatic telescopic 2 panel door 700,750 Automatic telescopic 3 panel door 600, 650, 700,750,800 Automatic telescopic 4 panel door 750,800; DoorsFireRatingMinimum: 120 Mins (telescopic), 60 or 120 (Hinged); DoorsFrameMaterial: Automatic telescopic 2 panel, Automatic telescopic, 3 panel Automatic telescopic 4 panel, Panel Door (single hinged), Panoramic Door (single hinged) Aluminium panoramic door (single hinged), Double inged door; DoorsFrameFinish: Similinox (Telescopic) 441 Stainless Steel (telescopic) 316 Stainless Steel (telescopic) Vimec 7040, Special RAL; DoorsFrameColour: Vimec 7040; DoorsInfillMaterial: Coated Steel Colour Type, Stainless Steel, Painted Steel; DoorsInfillFinish: Similinox (Telescopic) 441 Stainless Steel (telescopic) 316 Stainless Steel (telescopic) Vimec 7040, Special RAL; DoorsInfillColour: White, Similinox, Polished linen or brushed Stainless Steel, Special RAL; CarrierFloorDimensionsWidthMinimum: 1220mm; CarrierFloorDimensionsDepthMinimum: 970mm; CarrierFloorMaterial: PVC /Rubber, PVC,; CarrierFloorColour: PVC Rubber Grey floor with stamps PVC Red, dark grey, light grey, wild pear; WorkingLoad: 400 kg; PitDepthOptions: 120 mm for masonry shaft and aluminium guards; 140 mm for metal framework; Applications: Any environment, whether a home or a public building; Speed: 0,15 m/sec; Motor: 1.5 kW; AuxiliaryCircuit: 24V-dc; SafetySystems: OSG and mechanical safety gear; LiftingSystem: Two lifting cables with spring system for load division; LiftingTravel: 14600 mm; AutomaticSafetyLevelling: n/a; HeadroomOptions: 2450 mm, 2600 mm if cabin supplied with automatic telescopic door; Transmission: With electric motor and belts; IntermediateStops: Max 4 with a minimum distance between the stops of 350 mm for a min. technical distance of 200 mm; Guard: When there is a metal frame the roof for indoor or outdoor use can be ordered on request (mandatory for outdoor installations)
Type - Pset_TransportElementCommon - CapacityPeople: 5; CapacityWeight: 400; FireExit: no; Reference: n/a
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no; IK_Code: n/a; IP_Code: n/a; NominalFrequencyRange: n/a; NumberOfPoles: 0; PowerFactor: 0; RatedCurrent: 1.5 kW; RatedVoltage: 230 V
Type - IFC - IfcExportAs: IfcTransportElementType; IfcExportType: ELEVATOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_65_80_47_95:Vertical lifting platforms; CodePerformance: n/a; Color: Vimec 7040, Special RAL; Constituents: n/a; Description: Lifting system for a person with limited locomotory capacity; DurationUnit: year; ExpectedLife: 15 Years; Features: Internal or external application, on-board emergency push-button connected with an audible alarm, telephone; thermal circuit breaker on the motor, landing limit switch; over-run microswitch, pit and headroom under safety microswitches,; Finish: Coated with stainless steel; Grade: n/a; Manufacturer: info@vimec.biz; Material: n/a; ModelNumber: E10; ModelReference: ECOVimecE10_1250x1000mm; Name: VerticalLiftingPlatforms_ECOVimecE10_1250x1000mm_VimecAccessibilityLtd; NominalHeight: 2000 mm; NominalLength: 1000 mm; NominalWidth: 1250 mm; ReplacementCost: n/a; Shape: n/a; Size: 2000 x 1250 x 1000 mm; SustainabilityPerformance: n/a; WarrantyDescription: 2 Years warranty on parts; WarrantyDurationLabor: n/a; WarrantyDurationParts: Included; WarrantyDurationUnit: 2 years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
